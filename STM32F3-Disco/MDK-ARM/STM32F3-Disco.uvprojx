# Keil uVision project STM32F3-Disco.uvprojx, settings and files
target STM32F3-Disco (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F3-Disco
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xC
  c misc: --C99
  c include: ../Inc;    ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;    ../Drivers/STM32F3xx_HAL_Driver/Inc;    ../Drivers/CMSIS/Include;    ../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: gpio.c main.c stm32f3xx_hal_msp.c stm32f3xx_it.c stm32f3xx_hal_timebase_TIM.c freertos.c
  group Application/MDK-ARM
    ./: startup_stm32f303xc.s
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_pwr.c stm32f3xx_hal_i2c.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal.c stm32f3xx_hal_tim.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_tim_ex.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c timers.c event_groups.c list.c croutine.c queue.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 4.1.0
